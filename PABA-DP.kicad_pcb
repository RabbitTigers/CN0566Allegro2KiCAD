# Repository RabbitTigers/CN0566Allegro2KiCAD (continued)

## KiCad design PABA-DP.kicad_pcb (continued)

Schematic: 3.kicad_sch

Parts:
ANT1, ANT2, ANT3, ANT4, ANT5, ANT6, ANT7, ANT8, ANT9, ANT10, ANT11, ANT12, ANT13, ANT14, ANT15, ANT16, ANT17, ANT18, ANT19, ANT20, ANT21, ANT22, ANT23, ANT24, ANT25, ANT26, ANT27, ANT28, ANT29, ANT30, ANT31, ANT32: Patch_Ant; Patch Antenna

Connections:
AGND: ANT1.0_2 (GND), ANT1.0_3 (GND), ANT1.0_4 (GND), ANT1.0_5 (GND), ANT1.0_6 (GND), ANT1.0_7 (GND), ANT1.0_8 (GND), ANT1.0_9 (GND), ANT1.0_10 (GND), ANT1.0_11 (GND), ANT1.0_12 (GND), ANT1.0_13 (GND), ANT1.0_14 (GND), ANT1.0_15 (GND), ANT1.0_16 (GND), ANT1.0_17 (GND), ANT1.0_18 (GND), ANT1.0_19 (GND), ANT1.0_20 (GND), ANT1.0_21 (GND), ANT1.0_22 (GND), ANT1.0_23 (GND), ANT1.0_24 (GND), ANT1.0_25 (GND), ANT1.0_26 (GND), ANT1.0_27 (GND), ANT1.0_28 (GND), ANT1.0_29 (GND), ANT1.0_30 (GND), ANT1.0_31 (GND), ANT1.0_32 (GND), ANT1.0_33 (GND), ANT1.0_34 (GND), ANT1.0_35 (GND), ANT1.0_36 (GND), ANT2.0_2 (GND), ANT2.0_3 (GND), ANT2.0_4 (GND), ANT2.0_5 (GND), ANT2.0_6 (GND), ANT2.0_7 (GND), ANT2.0_8 (GND), ANT2.0_9 (GND), ANT2.0_10 (GND), ANT2.0_11 (GND), ANT2.0_12 (GND), ANT2.0_13 (GND), ANT2.0_14 (GND), ANT2.0_15 (GND), ANT2.0_16 (GND), ANT2.0_17 (GND), ANT2.0_18 (GND), ANT2.0_19 (GND), ANT2.0_20 (GND), ANT2.0_21 (GND), ANT2.0_22 (GND), ANT2.0_23 (GND), ANT2.0_24 (GND), ANT2.0_25 (GND), ANT2.0_26 (GND), ANT2.0_27 (GND), ANT2.0_28 (GND), ANT2.0_29 (GND), ANT2.0_30 (GND), ANT2.0_31 (GND), ANT2.0_32 (GND), ANT2.0_33 (GND), ANT2.0_34 (GND), ANT2.0_35 (GND), ANT2.0_36 (GND), ANT3.0_2 (GND), ANT3.0_3 (GND), ANT3.0_4 (GND), ANT3.0_5 (GND), ANT3.0_6 (GND), ANT3.0_7 (GND), ANT3.0_8 (GND), ANT3.0_9 (GND), ANT3.0_10 (GND), ANT3.0_11 (GND), ANT3.0_12 (GND), ANT3.0_13 (GND), ANT3.0_14 (GND), ANT3.0_15 (GND), ANT3.0_16 (GND), ANT3.0_17 (GND), ANT3.0_18 (GND), ANT3.0_19 (GND), ANT3.0_20 (GND), ANT3.0_21 (GND), ANT3.0_22 (GND), ANT3.0_23 (GND), ANT3.0_24 (GND), ANT3.0_25 (GND), ANT3.0_26 (GND), ANT3.0_27 (GND), ANT3.0_28 (GND), ANT3.0_29 (GND), ANT3.0_30 (GND), ANT3.0_31 (GND), ANT3.0_32 (GND), ANT3.0_33 (GND), ANT3.0_34 (GND), ANT3.0_35 (GND), ANT3.0_36 (GND), ANT4.0_2 (GND), ANT4.0_3 (GND), ANT4.0_4 (GND), ANT4.0_5 (GND), ANT4.0_6 (GND), ANT4.0_7 (GND), ANT4.0_8 (GND), ANT4.0_9 (GND), ANT4.0_10 (GND), ANT4.0_11 (GND), ANT4.0_12 (GND), ANT4.0_13 (GND), ANT4.0_14 (GND), ANT4.0_15 (GND), ANT4.0_16 (GND), ANT4.0_17 (GND), ANT4.0_18 (GND), ANT4.0_19 (GND), ANT4.0_20 (GND), ANT4.0_21 (GND), ANT4.0_22 (GND), ANT4.0_23 (GND), ANT4.0_24 (GND), ANT4.0_25 (GND), ANT4.0_26 (GND), ANT4.0_27 (GND), ANT4.0_28 (GND), ANT4.0_29 (GND), ANT4.0_30 (GND), ANT4.0_31 (GND), ANT4.0_32 (GND), ANT4.0_33 (GND), ANT4.0_34 (GND), ANT4.0_35 (GND), ANT4.0_36 (GND), ANT5.0_2 (GND), ANT5.0_3 (GND), ANT5.0_4 (GND), ANT5.0_5 (GND), ANT5.0_6 (GND), ANT5.0_7 (GND), ANT5.0_8 (GND), ANT5.0_9 (GND), ANT5.0_10 (GND), ANT5.0_11 (GND), ANT5.0_12 (GND), ANT5.0_13 (GND), ANT5.0_14 (GND), ANT5.0_15 (GND), ANT5.0_16 (GND), ANT5.0_17 (GND), ANT5.0_18 (GND), ANT5.0_19 (GND), ANT5.0_20 (GND), ANT5.0_21 (GND), ANT5.0_22 (GND), ANT5.0_23 (GND), ANT5.0_24 (GND), ANT5.0_25 (GND), ANT5.0_26 (GND), ANT5.0_27 (GND), ANT5.0_28 (GND), ANT5.0_29 (GND), ANT5.0_30 (GND), ANT5.0_31 (GND), ANT5.0_32 (GND), ANT5.0_33 (GND), ANT5.0_34 (GND), ANT5.0_35 (GND), ANT5.0_36 (GND), ANT6.0_2 (GND), ANT6.0_3 (GND), ANT6.0_4 (GND), ANT6.0_5 (GND), ANT6.0_6 (GND), ANT6.0_7 (GND), ANT6.0_8 (GND), ANT6.0_9 (GND), ANT6.0_10 (GND), ANT6.0_11 (GND), ANT6.0_12 (GND), ANT6.0_13 (GND), ANT6.0_14 (GND), ANT6.0_15 (GND), ANT6.0_16 (GND), ANT6.0_17 (GND), ANT6.0_18 (GND), ANT6.0_19 (GND), ANT6.0_20 (GND), ANT6.0_21 (GND), ANT6.0_22 (GND), ANT6.0_23 (GND), ANT6.0_24 (GND), ANT6.0_25 (GND), ANT6.0_26 (GND), ANT6.0_27 (GND), ANT6.0_28 (GND), ANT6.0_29 (GND), ANT6.0_30 (GND), ANT6.0_31 (GND), ANT6.0_32 (GND), ANT6.0_33 (GND), ANT6.0_34 (GND), ANT6.0_35 (GND), ANT6.0_36 (GND), ANT7.0_2 (GND), ANT7.0_3 (GND), ANT7.0_4 (GND), ANT7.0_5 (GND), ANT7.0_6 (GND), ANT7.0_7 (GND), ANT7.0_8 (GND), ANT7.0_9 (GND), ANT7.0_10 (GND), ANT7.0_11 (GND), ANT7.0_12 (GND), ANT7.0_13 (GND), ANT7.0_14 (GND), ANT7.0_15 (GND), ANT7.0_16 (GND), ANT7.0_17 (GND), ANT7.0_18 (GND), ANT7.0_19 (GND), ANT7.0_20 (GND), ANT7.0_21 (GND), ANT7.0_22 (GND), ANT7.0_23 (GND), ANT7.0_24 (GND), ANT7.0_25 (GND), ANT7.0_26 (GND), ANT7.0_27 (GND), ANT7.0_28 (GND), ANT7.0_29 (GND), ANT7.0_30 (GND), ANT7.0_31 (GND), ANT7.0_32 (GND), ANT7.0_33 (GND), ANT7.0_34 (GND), ANT7.0_35 (GND), ANT7.0_36 (GND), ANT8.0_2 (GND), ANT8.0_3 (GND), ANT8.0_4 (GND), ANT8.0_5 (GND), ANT8.0_6 (GND), ANT8.0_7 (GND), ANT8.0_8 (GND), ANT8.0_9 (GND), ANT8.0_10 (GND), ANT8.0_11 (GND), ANT8.0_12 (GND), ANT8.0_13 (GND), ANT8.0_14 (GND), ANT8.0_15 (GND), ANT8.0_16 (GND), ANT8.0_17 (GND), ANT8.0_18 (GND), ANT8.0_19 (GND), ANT8.0_20 (GND), ANT8.0_21 (GND), ANT8.0_22 (GND), ANT8.0_23 (GND), ANT8.0_24 (GND), ANT8.0_25 (GND), ANT8.0_26 (GND), ANT8.0_27 (GND), ANT8.0_28 (GND), ANT8.0_29 (GND), ANT8.0_30 (GND), ANT8.0_31 (GND), ANT8.0_32 (GND), ANT8.0_33 (GND), ANT8.0_34 (GND), ANT8.0_35 (GND), ANT8.0_36 (GND), ANT9.0_2 (GND), ANT9.0_3 (GND), ANT9.0_4 (GND), ANT9.0_5 (GND), ANT9.0_6 (GND), ANT9.0_7 (GND), ANT9.0_8 (GND), ANT9.0_9 (GND), ANT9.0_10 (GND), ANT9.0_11 (GND), ANT9.0_12 (GND), ANT9.0_13 (GND), ANT9.0_14 (GND), ANT9.0_15 (GND), ANT9.0_16 (GND), ANT9.0_17 (GND), ANT9.0_18 (GND), ANT9.0_19 (GND), ANT9.0_20 (GND), ANT9.0_21 (GND), ANT9.0_22 (GND), ANT9.0_23 (GND), ANT9.0_24 (GND), ANT9.0_25 (GND), ANT9.0_26 (GND), ANT9.0_27 (GND), ANT9.0_28 (GND), ANT9.0_29 (GND), ANT9.0_30 (GND), ANT9.0_31 (GND), ANT9.0_32 (GND), ANT9.0_33 (GND), ANT9.0_34 (GND), ANT9.0_35 (GND), ANT9.0_36 (GND), ANT10.0_2 (GND), ANT10.0_3 (GND), ANT10.0_4 (GND), ANT10.0_5 (GND), ANT10.0_6 (GND), ANT10.0_7 (GND), ANT10.0_8 (GND), ANT10.0_9 (GND), ANT10.0_10 (GND), ANT10.0_11 (GND), ANT10.0_12 (GND), ANT10.0_13 (GND), ANT10.0_14 (GND), ANT10.0_15 (GND), ANT10.0_16 (GND), ANT10.0_17 (GND), ANT10.0_18 (GND), ANT10.0_19 (GND), ANT10.0_20 (GND), ANT10.0_21 (GND), ANT10.0_22 (GND), ANT10.0_23 (GND), ANT10.0_24 (GND), ANT10.0_25 (GND), ANT10.0_26 (GND), ANT10.0_27 (GND), ANT10.0_28 (GND), ANT10.0_29 (GND), ANT10.0_30 (GND), ANT10.0_31 (GND), ANT10.0_32 (GND), ANT10.0_33 (GND), ANT10.0_34 (GND), ANT10.0_35 (GND), ANT10.0_36 (GND), ANT11.0_2 (GND), ANT11.0_3 (GND), ANT11.0_4 (GND), ANT11.0_5 (GND), ANT11.0_6 (GND), ANT11.0_7 (GND), ANT11.0_8 (GND), ANT11.0_9 (GND), ANT11.0_10 (GND), ANT11.0_11 (GND), ANT11.0_12 (GND), ANT11.0_13 (GND), ANT11.0_14 (GND), ANT11.0_15 (GND), ANT11.0_16 (GND), ANT11.0_17 (GND), ANT11.0_18 (GND), ANT11.0_19 (GND), ANT11.0_20 (GND), ANT11.0_21 (GND), ANT11.0_22 (GND), ANT11.0_23 (GND), ANT11.0_24 (GND), ANT11.0_25 (GND), ANT11.0_26 (GND), ANT11.0_27 (GND), ANT11.0_28 (GND), ANT11.0_29 (GND), ANT11.0_30 (GND), ANT11.0_31 (GND), ANT11.0_32 (GND), ANT11.0_33 (GND), ANT11.0_34 (GND), ANT11.0_35 (GND), ANT11.0_36 (GND), ANT12.0_2 (GND), ANT12.0_3 (GND), ANT12.0_4 (GND), ANT12.0_5 (GND), ANT12.0_6 (GND), ANT12.0_7 (GND), ANT12.0_8 (GND), ANT12.0_9 (GND), ANT12.0_10 (GND), ANT12.0_11 (GND), ANT12.0_12 (GND), ANT12.0_13 (GND), ANT12.0_14 (GND), ANT12.0_15 (GND), ANT12.0_16 (GND), ANT12.0_17 (GND), ANT12.0_18 (GND), ANT12.0_19 (GND), ANT12.0_20 (GND), ANT12.0_21 (GND), ANT12.0_22 (GND), ANT12.0_23 (GND), ANT12.0_24 (GND), ANT12.0_25 (GND), ANT12.0_26 (GND), ANT12.0_27 (GND), ANT12.0_28 (GND), ANT12.0_29 (GND), ANT12.0_30 (GND), ANT12.0_31 (GND), ANT12.0_32 (GND), ANT12.0_33 (GND), ANT12.0_34 (GND), ANT12.0_35 (GND), ANT12.0_36 (GND), ANT13.0_2 (GND), ANT13.0_3 (GND), ANT13.0_4 (GND), ANT13.0_5 (GND), ANT13.0_6 (GND), ANT13.0_7 (GND), ANT13.0_8 (GND), ANT13.0_9 (GND), ANT13.0_10 (GND), ANT13.0_11 (GND), ANT13.0_12 (GND), ANT13.0_13 (GND), ANT13.0_14 (GND), ANT13.0_15 (GND), ANT13.0_16 (GND), ANT13.0_17 (GND), ANT13.0_18 (GND), ANT13.0_19 (GND), ANT13.0_20 (GND), ANT13.0_21 (GND), ANT13.0_22 (GND), ANT13.0_23 (GND), ANT13.0_24 (GND), ANT13.0_25 (GND), ANT13.0_26 (GND), ANT13.0_27 (GND), ANT13.0_28 (GND), ANT13.0_29 (GND), ANT13.0_30 (GND), ANT13.0_31 (GND), ANT13.0_32 (GND), ANT13.0_33 (GND), ANT13.0_34 (GND), ANT13.0_35 (GND), ANT13.0_36 (GND), ANT14.0_2 (GND), ANT14.0_3 (GND), ANT14.0_4 (GND), ANT14.0_5 (GND), ANT14.0_6 (GND), ANT14.0_7 (GND), ANT14.0_8 (GND), ANT14.0_9 (GND), ANT14.0_10 (GND), ANT14.0_11 (GND), ANT14.0_12 (GND), ANT14.0_13 (GND), ANT14.0_14 (GND), ANT14.0_15 (GND), ANT14.0_16 (GND), ANT14.0_17 (GND), ANT14.0_18 (GND), ANT14.0_19 (GND), ANT14.0_20 (GND), ANT14.0_21 (GND), ANT14.0_22 (GND), ANT14.0_23 (GND), ANT14.0_24 (GND), ANT14.0_25 (GND), ANT14.0_26 (GND), ANT14.0_27 (GND), ANT14.0_28 (GND), ANT14.0_29 (GND), ANT14.0_30 (GND), ANT14.0_31 (GND), ANT14.0_32 (GND), ANT14.0_33 (GND), ANT14.0_34 (GND), ANT14.0_35 (GND), ANT14.0_36 (GND), ANT15.0_2 (GND), ANT15.0_3 (GND), ANT15.0_4 (GND), ANT15.0_5 (GND), ANT15.0_6 (GND), ANT15.0_7 (GND), ANT15.0_8 (GND), ANT15.0_9 (GND), ANT15.0_10 (GND), ANT15.0_11 (GND), ANT15.0_12 (GND), ANT15.0_13 (GND), ANT15.0_14 (GND), ANT15.0_15 (GND), ANT15.0_16 (GND), ANT15.0_17 (GND), ANT15.0_18 (GND), ANT15.0_19 (GND), ANT15.0_20 (GND), ANT15.0_21 (GND), ANT15.0_22 (GND), ANT15.0_23 (GND), ANT15.0_24 (GND), ANT15.0_25 (GND), ANT15.0_26 (GND), ANT15.0_27 (GND), ANT15.0_28 (GND), ANT15.0_29 (GND), ANT15.0_30 (GND), ANT15.0_31 (GND), ANT15.0_32 (GND), ANT15.0_33 (GND), ANT15.0_34 (GND), ANT15.0_35 (GND), ANT15.0_36 (GND), ANT16.0_2 (GND), ANT16.0_3 (GND), ANT16.0_4 (GND), ANT16.0_5 (GND), ANT16.0_6 (GND), ANT16.0_7 (GND), ANT16.0_8 (GND), ANT16.0_9 (GND), ANT16.0_10 (GND), ANT16.0_11 (GND), ANT16.0_12 (GND), ANT16.0_13 (GND), ANT16.0_14 (GND), ANT16.0_15 (GND), ANT16.0_16 (GND), ANT16.0_17 (GND), ANT16.0_18 (GND), ANT16.0_19 (GND), ANT16.0_20 (GND), ANT16.0_21 (GND), ANT16.0_22 (GND), ANT16.0_23 (GND), ANT16.0_24 (GND), ANT16.0_25 (GND), ANT16.0_26 (GND), ANT16.0_27 (GND), ANT16.0_28 (GND), ANT16.0_29 (GND), ANT16.0_30 (GND), ANT16.0_31 (GND), ANT16.0_32 (GND), ANT16.0_33 (GND), ANT16.0_34 (GND), ANT16.0_35 (GND), ANT16.0_36 (GND), ANT17.0_2 (GND), ANT17.0_3 (GND), ANT17.0_4 (GND), ANT17.0_5 (GND), ANT17.0_6 (GND), ANT17.0_7 (GND), ANT17.0_8 (GND), ANT17.0_9 (GND), ANT17.0_10 (GND), ANT17.0_11 (GND), ANT17.0_12 (GND), ANT17.0_13 (GND), ANT17.0_14 (GND), ANT17.0_15 (GND), ANT17.0_16 (GND), ANT17.0_17 (GND), ANT17.0_18 (GND), ANT17.0_19 (GND), ANT17.0_20 (GND), ANT17.0_21 (GND), ANT17.0_22 (GND), ANT17.0_23 (GND), ANT17.0_24 (GND), ANT17.0_25 (GND), ANT17.0_26 (GND), ANT17.0_27 (GND), ANT17.0_28 (GND), ANT17.0_29 (GND), ANT17.0_30 (GND), ANT17.0_31 (GND), ANT17.0_32 (GND), ANT17.0_33 (GND), ANT17.0_34 (GND), ANT17.0_35 (GND), ANT17.0_36 (GND), ANT18.0_2 (GND), ANT18.0_3 (GND), ANT18.0_4 (GND), ANT18.0_5 (GND), ANT18.0_6 (GND), ANT18.0_7 (GND), ANT18.0_8 (GND), ANT18.0_9 (GND), ANT18.0_10 (GND), ANT18.0_11 (GND), ANT18.0_12 (GND), ANT18.0_13 (GND), ANT18.0_14 (GND), ANT18.0_15 (GND), ANT18.0_16 (GND), ANT18.0_17 (GND), ANT18.0_18 (GND), ANT18.0_19 (GND), ANT18.0_20 (GND), ANT18.0_21 (GND), ANT18.0_22 (GND), ANT18.0_23 (GND), ANT18.0_24 (GND), ANT18.0_25 (GND), ANT18.0_26 (GND), ANT18.0_27 (GND), ANT18.0_28 (GND), ANT18.0_29 (GND), ANT18.0_30 (GND), ANT18.0_31 (GND), ANT18.0_32 (GND), ANT18.0_33 (GND), ANT18.0_34 (GND), ANT18.0_35 (GND), ANT18.0_36 (GND), ANT19.0_2 (GND), ANT19.0_3 (GND), ANT19.0_4 (GND), ANT19.0_5 (GND), ANT19.0_6 (GND), ANT19.0_7 (GND), ANT19.0_8 (GND), ANT19.0_9 (GND), ANT19.0_10 (GND), ANT19.0_11 (GND), ANT19.0_12 (GND), ANT19.0_13 (GND), ANT19.0_14 (GND), ANT19.0_15 (GND), ANT19.0_16 (GND), ANT19.0_17 (GND), ANT19.0_18 (GND), ANT19.0_19 (GND), ANT19.0_20 (GND), ANT19.0_21 (GND), ANT19.0_22 (GND), ANT19.0_23 (GND), ANT19.0_24 (GND), ANT19.0_25 (GND), ANT19.0_26 (GND), ANT19.0_27 (GND), ANT19.0_28 (GND), ANT19.0_29 (GND), ANT19.0_30 (GND), ANT19.0_31 (GND), ANT19.0_32 (GND), ANT19.0_33 (GND), ANT19.0_34 (GND), ANT19.0_35 (GND), ANT19.0_36 (GND), ANT20.0_2 (GND), ANT20.0_3 (GND), ANT20.0_4 (GND), ANT20.0_5 (GND), ANT20.0_6 (GND), ANT20.0_7 (GND), ANT20.0_8 (GND), ANT20.0_9 (GND), ANT20.0_10 (GND), ANT20.0_11 (GND), ANT20.0_12 (GND), ANT20.0_13 (GND), ANT20.0_14 (GND), ANT20.0_15 (GND), ANT20.0_16 (GND), ANT20.0_17 (GND), ANT20.0_18 (GND), ANT20.0_19 (GND), ANT20.0_20 (GND), ANT20.0_21 (GND), ANT20.0_22 (GND), ANT20.0_23 (GND), ANT20.0_24 (GND), ANT20.0_25 (GND), ANT20.0_26 (GND), ANT20.0_27 (GND), ANT20.0_28 (GND), ANT20.0_29 (GND), ANT20.0_30 (GND), ANT20.0_31 (GND), ANT20.0_32 (GND), ANT20.0_33 (GND), ANT20.0_34 (GND), ANT20.0_35 (GND), ANT20.0_36 (GND), ANT21.0_2 (GND), ANT21.0_3 (GND), ANT21.0_4 (GND), ANT21.0_5 (GND), ANT21.0_6 (GND), ANT21.0_7 (GND), ANT21.0_8 (GND), ANT21.0_9 (GND), ANT21.0_10 (GND), ANT21.0_11 (GND), ANT21.0_12 (GND), ANT21.0_13 (GND), ANT21.0_14 (GND), ANT21.0_15 (GND), ANT21.0_16 (GND), ANT21.0_17 (GND), ANT21.0_18 (GND), ANT21.0_19 (GND), ANT21.0_20 (GND), ANT21.0_21 (GND), ANT21.0_22 (GND), ANT21.0_23 (GND), ANT21.0_24 (GND), ANT21.0_25 (GND), ANT21.0_26 (GND), ANT21.0_27 (GND), ANT21.0_28 (GND), ANT21.0_29 (GND), ANT21.0_30 (GND), ANT21.0_31 (GND), ANT21.0_32 (GND), ANT21.0_33 (GND), ANT21.0_34 (GND), ANT21.0_35 (GND), ANT21.0_36 (GND), ANT22.0_2 (GND), ANT22.0_3 (GND), ANT22.0_4 (GND), ANT22.0_5 (GND), ANT22.0_6 (GND), ANT22.0_7 (GND), ANT22.0_8 (GND), ANT22.0_9 (GND), ANT22.0_10 (GND), ANT22.0_11 (GND), ANT22.0_12 (GND), ANT22.0_13 (GND), ANT22.0_14 (GND), ANT22.0_15 (GND), ANT22.0_16 (GND), ANT22.0_17 (GND), ANT22.0_18 (GND), ANT22.0_19 (GND), ANT22.0_20 (GND), ANT22.0_21 (GND), ANT22.0_22 (GND), ANT22.0_23 (GND), ANT22.0_24 (GND), ANT22.0_25 (GND), ANT22.0_26 (GND), ANT22.0_27 (GND), ANT22.0_28 (GND), ANT22.0_29 (GND), ANT22.0_30 (GND), ANT22.0_31 (GND), ANT22.0_32 (GND), ANT22.0_33 (GND), ANT22.0_34 (GND), ANT22.0_35 (GND), ANT22.0_36 (GND), ANT23.0_2 (GND), ANT23.0_3 (GND), ANT23.0_4 (GND), ANT23.0_5 (GND), ANT23.0_6 (GND), ANT23.0_7 (GND), ANT23.0_8 (GND), ANT23.0_9 (GND), ANT23.0_10 (GND), ANT23.0_11 (GND), ANT23.0_12 (GND), ANT23.0_13 (GND), ANT23.0_14 (GND), ANT23.0_15 (GND), ANT23.0_16 (GND), ANT23.0_17 (GND), ANT23.0_18 (GND), ANT23.0_19 (GND), ANT23.0_20 (GND), ANT23.0_21 (GND), ANT23.0_22 (GND), ANT23.0_23 (GND), ANT23.0_24 (GND), ANT23.0_25 (GND), ANT23.0_26 (GND), ANT23.0_27 (GND), ANT23.0_28 (GND), ANT23.0_29 (GND), ANT23.0_30 (GND), ANT23.0_31 (GND), ANT23.0_32 (GND), ANT23.0_33 (GND), ANT23.0_34 (GND), ANT23.0_35 (GND), ANT23.0_36 (GND), ANT24.0_2 (GND), ANT24.0_3 (GND), ANT24.0_4 (GND), ANT24.0_5 (GND), ANT24.0_6 (GND), ANT24.0_7 (GND), ANT24.0_8 (GND), ANT24.0_9 (GND), ANT24.0_10 (GND), ANT24.0_11 (GND), ANT24.0_12 (GND), ANT24.0_13 (GND), ANT24.0_14 (GND), ANT24.0_15 (GND), ANT24.0_16 (GND), ANT24.0_17 (GND), ANT24.0_18 (GND), ANT24.0_19 (GND), ANT24.0_20 (GND), ANT24.0_21 (GND), ANT24.0_22 (GND), ANT24.0_23 (GND), ANT24.0_24 (GND), ANT24.0_25 (GND), ANT24.0_26 (GND), ANT24.0_27 (GND), ANT24.0_28 (GND), ANT24.0_29 (GND), ANT24.0_30 (GND), ANT24.0_31 (GND), ANT24.0_32 (GND), ANT24.0_33 (GND), ANT24.0_34 (GND), ANT24.0_35 (GND), ANT24.0_36 (GND), ANT25.0_2 (GND), ANT25.0_3 (GND), ANT25.0_4 (GND), ANT25.0_5 (GND), ANT25.0_6 (GND), ANT25.0_7 (GND), ANT25.0_8 (GND), ANT25.0_9 (GND), ANT25.0_10 (GND), ANT25.0_11 (GND), ANT25.0_12 (GND), ANT25.0_13 (GND), ANT25.0_14 (GND), ANT25.0_15 (GND), ANT25.0_16 (GND), ANT25.0_17 (GND), ANT25.0_18 (GND), ANT25.0_19 (GND), ANT25.0_20 (GND), ANT25.0_21 (GND), ANT25.0_22 (GND), ANT25.0_23 (GND), ANT25.0_24 (GND), ANT25.0_25 (GND), ANT25.0_26 (GND), ANT25.0_27 (GND), ANT25.0_28 (GND), ANT25.0_29 (GND), ANT25.0_30 (GND), ANT25.0_31 (GND), ANT25.0_32 (GND), ANT25.0_33 (GND), ANT25.0_34 (GND), ANT25.0_35 (GND), ANT25.0_36 (GND), ANT26.0_2 (GND), ANT26.0_3 (GND), ANT26.0_4 (GND), ANT26.0_5 (GND), ANT26.0_6 (GND), ANT26.0_7 (GND), ANT26.0_8 (GND), ANT26.0_9 (GND), ANT26.0_10 (GND), ANT26.0_11 (GND), ANT26.0_12 (GND), ANT26.0_13 (GND), ANT26.0_14 (GND), ANT26.0_15 (GND), ANT26.0_16 (GND), ANT26.0_17 (GND), ANT26.0_18 (GND), ANT26.0_19 (GND), ANT26.0_20 (GND), ANT26.0_21 (GND), ANT26.0_22 (GND), ANT26.0_23 (GND), ANT26.0_24 (GND), ANT26.0_25 (GND), ANT26.0_26 (GND), ANT26.0_27 (GND), ANT26.0_28 (GND), ANT26.0_29 (GND), ANT26.0_30 (GND), ANT26.0_31 (GND), ANT26.0_32 (GND), ANT26.0_33 (GND), ANT26.0_34 (GND), ANT26.0_35 (GND), ANT26.0_36 (GND), ANT27.0_2 (GND), ANT27.0_3 (GND), ANT27.0_4 (GND), ANT27.0_5 (GND), ANT27.0_6 (GND), ANT27.0_7 (GND), ANT27.0_8 (GND), ANT27.0_9 (GND), ANT27.0_10 (GND), ANT27.0_11 (GND), ANT27.0_12 (GND), ANT27.0_13 (GND), ANT27.0_14 (GND), ANT27.0_15 (GND), ANT27.0_16 (GND), ANT27.0_17 (GND), ANT27.0_18 (GND), ANT27.0_19 (GND), ANT27.0_20 (GND), ANT27.0_21 (GND), ANT27.0_22 (GND), ANT27.0_23 (GND), ANT27.0_24 (GND), ANT27.0_25 (GND), ANT27.0_26 (GND), ANT27.0_27 (GND), ANT27.0_28 (GND), ANT27.0_29 (GND), ANT27.0_30 (GND), ANT27.0_31 (GND), ANT27.0_32 (GND), ANT27.0_33 (GND), ANT27.0_34 (GND), ANT27.0_35 (GND), ANT27.0_36 (GND), ANT28.0_2 (GND), ANT28.0_3 (GND), ANT28.0_4 (GND), ANT28.0_5 (GND), ANT28.0_6 (GND), ANT28.0_7 (GND), ANT28.0_8 (GND), ANT28.0_9 (GND), ANT28.0_10 (GND), ANT28.0_11 (GND), ANT28.0_12 (GND), ANT28.0_13 (GND), ANT28.0_14 (GND), ANT28.0_15 (GND), ANT28.0_16 (GND), ANT28.0_17 (GND), ANT28.0_18 (GND), ANT28.0_19 (GND), ANT28.0_20 (GND), ANT28.0_21 (GND), ANT28.0_22 (GND), ANT28.0_23 (GND), ANT28.0_24 (GND), ANT28.0_25 (GND), ANT28.0_26 (GND), ANT28.0_27 (GND), ANT28.0_28 (GND), ANT28.0_29 (GND), ANT28.0_30 (GND), ANT28.0_31 (GND), ANT28.0_32 (GND), ANT28.0_33 (GND), ANT28.0_34 (GND), ANT28.0_35 (GND), ANT28.0_36 (GND), ANT29.0_2 (GND), ANT29.0_3 (GND), ANT29.0_4 (GND), ANT29.0_5 (GND), ANT29.0_6 (GND), ANT29.0_7 (GND), ANT29.0_8 (GND), ANT29.0_9 (GND), ANT29.0_10 (GND), ANT29.0_11 (GND), ANT29.0_12 (GND), ANT29.0_13 (GND), ANT29.0_14 (GND), ANT29.0_15 (GND), ANT29.0_16 (GND), ANT29.0_17 (GND), ANT29.0_18 (GND), ANT29.0_19 (GND), ANT29.0_20 (GND), ANT29.0_21 (GND), ANT29.0_22 (GND), ANT29.0_23 (GND), ANT29.0_24 (GND), ANT29.0_25 (GND), ANT29.0_26 (GND), ANT29.0_27 (GND), ANT29.0_28 (GND), ANT29.0_29 (GND), ANT29.0_30 (GND), ANT29.0_31 (GND), ANT29.0_32 (GND), ANT29.0_33 (GND), ANT29.0_34 (GND), ANT29.0_35 (GND), ANT29.0_36 (GND), ANT30.0_2 (GND), ANT30.0_3 (GND), ANT30.0_4 (GND), ANT30.0_5 (GND), ANT30.0_6 (GND), ANT30.0_7 (GND), ANT30.0_8 (GND), ANT30.0_9 (GND), ANT30.0_10 (GND), ANT30.0_11 (GND), ANT30.0_12 (GND), ANT30.0_13 (GND), ANT30.0_14 (GND), ANT30.0_15 (GND), ANT30.0_16 (GND), ANT30.0_17 (GND), ANT30.0_18 (GND), ANT30.0_19 (GND), ANT30.0_20 (GND), ANT30.0_21 (GND), ANT30.0_22 (GND), ANT30.0_23 (GND), ANT30.0_24 (GND), ANT30.0_25 (GND), ANT30.0_26 (GND), ANT30.0_27 (GND), ANT30.0_28 (GND), ANT30.0_29 (GND), ANT30.0_30 (GND), ANT30.0_31 (GND), ANT30.0_32 (GND), ANT30.0_33 (GND), ANT30.0_34 (GND), ANT30.0_35 (GND), ANT30.0_36 (GND), ANT31.0_2 (GND), ANT31.0_3 (GND), ANT31.0_4 (GND), ANT31.0_5 (GND), ANT31.0_6 (GND), ANT31.0_7 (GND), ANT31.0_8 (GND), ANT31.0_9 (GND), ANT31.0_10 (GND), ANT31.0_11 (GND), ANT31.0_12 (GND), ANT31.0_13 (GND), ANT31.0_14 (GND), ANT31.0_15 (GND), ANT31.0_16 (GND), ANT31.0_17 (GND), ANT31.0_18 (GND), ANT31.0_19 (GND), ANT31.0_20 (GND), ANT31.0_21 (GND), ANT31.0_22 (GND), ANT31.0_23 (GND), ANT31.0_24 (GND), ANT31.0_25 (GND), ANT31.0_26 (GND), ANT31.0_27 (GND), ANT31.0_28 (GND), ANT31.0_29 (GND), ANT31.0_30 (GND), ANT31.0_31 (GND), ANT31.0_32 (GND), ANT31.0_33 (GND), ANT31.0_34 (GND), ANT31.0_35 (GND), ANT31.0_36 (GND), ANT32.0_2 (GND), ANT32.0_3 (GND), ANT32.0_4 (GND), ANT32.0_5 (GND), ANT32.0_6 (GND), ANT32.0_7 (GND), ANT32.0_8 (GND), ANT32.0_9 (GND), ANT32.0_10 (GND), ANT32.0_11 (GND), ANT32.0_12 (GND), ANT32.0_13 (GND), ANT32.0_14 (GND), ANT32.0_15 (GND), ANT32.0_16 (GND), ANT32.0_17 (GND), ANT32.0_18 (GND), ANT32.0_19 (GND), ANT32.0_20 (GND), ANT32.0_21 (GND), ANT32.0_22 (GND), ANT32.0_23 (GND), ANT32.0_24 (GND), ANT32.0_25 (GND), ANT32.0_26 (GND), ANT32.0_27 (GND), ANT32.0_28 (GND), ANT32.0_29 (GND), ANT32.0_30 (GND), ANT32.0_31 (GND), ANT32.0_32 (GND), ANT32.0_33 (GND), ANT32.0_34 (GND), ANT32.0_35 (GND), ANT32.0_36 (GND); also elsewhere on the board

Notes on the sheet:
ANTENNA ARRAY

Schematic: 7.kicad_sch

Parts:
C9, C86: CC0603KRX7R9BB101; C_0603_1608Metric
C76: CL10A105KB8NNNC; C_0603_1608Metric
C80, C84: 02011JR15ZBSTR; C_0201_0603Metric
C83: 06035C220JAT2A; C_0603_1608Metric
C85: GRM0335C1E220JA01D; C_0201_0603Metric
C87: CL10B104KA8NNNC; C_0603_1608Metric
FL3: BFCN-1052+; BFCN1052
FL4: LFCW-1062+
FL7: LFCG-2500+; LFCG2500
OUT1, OUT2: 60312202114513
P4, P5, P7, P12, P13, P19: 36900000
R91, R124, R164: ERJ-3EKF1002V; R_0603_1608Metric
T2: TC1-1-13M+
TXIN1: 60312202114513
U7: LTC5548IUDB#TRPBF
U10: ADRF5019BCPZN; LFCSP-16-1EP_3x3mm_P0.5mm_EP1.7x1.7mm
U12: HMC654LP2E; HMC652LP2E TDFN 2x2
U13: ADL8107ACPZN; ADL8107ACPZN-R7

Connections:
AGND: C9.2, C76.2, C80.2, C83.2, C84.2, C86.2, C87.2, FL3.2 (GND), FL3.4 (GND), FL4.2 (GND), FL4.4 (GND), FL7.1 (GND), FL7.2 (GND), FL7.3 (GND), FL7.5 (GND), FL7.6 (GND), FL7.7 (GND), OUT1.2, OUT1.3, OUT1.4, OUT1.5, OUT2.2, OUT2.3, OUT2.4, OUT2.5, P4.1, P4.2, P4.3, P4.4, P4.5, P5.1, P5.2, P5.3, P5.4, P5.5, P7.1, P7.2, P7.3, P7.4, P7.5, P12.1, P12.2, P12.3, P12.4, P12.5, P13.1, P13.2, P13.3, P13.4, P13.5, P19.1, P19.2, P19.3, P19.4, P19.5, R164.2, T2.1, TXIN1.2, TXIN1.3, TXIN1.4, TXIN1.5, U7.1 (GND), U7.4 (GND), U7.6 (GND), U7.8 (X2), U7.10 (GND), U7.12 (GND), U7.13 (GND), U10.1 (GND), U10.2 (GND), U10.4 (GND), U10.5 (GND), U10.6 (GND), U10.8 (GND), U10.9 (VSS), U10.11 (LS), U10.13 (GND), U10.15 (GND), U10.16 (GND), U10.17 (GND), U12.1 (GND), U12.3 (GND), U12.4 (GND), U12.6 (GND), U12.7 (PAD), U13.2 (GND), U13.4 (GND), U13.5 (GND), U13.7 (GND), U13.9 (PAD); also elsewhere on the board
IF_IN: FL7.4 (RFOUT), T2.3
LO_IN_2: U12.2 (RF1); also elsewhere on the board
unnamed: FL3.1 (IN), U13.6 (RFOUT)
unnamed: FL3.3 (OUT), U10.3 (RFC)
unnamed: C80.1, FL4.1 (RFIN), U7.5 (RF)
unnamed: FL4.3 (RFOUT), U13.3 (RFIN)
unnamed: T2.4, U7.2 (IF+)
unnamed: T2.6, U7.3 (IF-)
unnamed: C84.1, C85.1, U7.11 (LO)
unnamed: OUT1.1, U10.14 (RF1)
unnamed: OUT2.1, U10.7 (RF2)
unnamed: C85.2, U12.5 (RF2)
unnamed: R124.1, U13.1 (RBIAS)
TX_IN: FL7.8 (RFIN), TXIN1.1
TX_SWITCH: R91.1, R164.1, U10.10 (VCTRL); also elsewhere on the board
VCTRL_2: U7.7 (EN); also elsewhere on the board
VDD_3V3: C9.1, C76.1, C83.1, R91.2, U7.9 (VCC), U10.12 (VDD); also elsewhere on the board
VDD_4V5: C86.1, C87.1, R124.2, U13.8 (VDD); also elsewhere on the board

Notes on the sheet:
TX_IN, TX_OUT_1,TX_OUT_2

Board: 2 copper layers, 502 parts (27 on the bottom side), 269 nets, no tracks yet.
